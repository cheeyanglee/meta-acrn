IMAGE_FSTYPES += "ext4"

WKS_FILE = "acrn-bootdisk.wks.in"
