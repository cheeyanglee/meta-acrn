require acrn-kernel.inc

SRC_URI_append = "  file://uos_5.4.scc"

LINUX_VERSION_EXTENSION = "-acrn-kernel-uos"

SUMMARY = "ACRN Kernel (UOS)"
